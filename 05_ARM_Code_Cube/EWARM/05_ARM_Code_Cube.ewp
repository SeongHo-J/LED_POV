# IAR project 05_ARM_Code_Cube.ewp, settings and files
configuration 05_ARM_Code_Cube Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 05_ARM_Code_Cube.hex
  ILINK.IlinkOutputFile: 05_ARM_Code_Cube Configuration.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s startup_stm32f429xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Drivers/
    ./: 
